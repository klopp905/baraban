/* Includes ------------------------------------------------------------------*/
#include "pi.h"
#include "main.h"
#include <math.h>

/* Private typedef -----------------------------------------------------------*/
/* Private define ------------------------------------------------------------*/
/* Private macro -------------------------------------------------------------*/
/* Private variables ---------------------------------------------------------*/


/* Private function prototypes -----------------------------------------------*/
/* Private functions ---------------------------------------------------------*/
//static	float ApplyDeadzone(float error); 
//static	float ApplyHysteresis(float input);

/*
//float deadzone = 5.0f; // Зона нечувствительности
//===========================================================================================
float ApplyDeadzone(float error) {
    if (fabs(error) < deadzone) {
        return 0.0f;
    }
    return error;
}
//===========================================================================================
*/


//===========================================================================================
/*float ApplyHysteresis(float input) {
    if (input > lastOutput + hysteresis) {
        lastOutput = input - hysteresis;
    } else if (input < lastOutput - hysteresis) {
        lastOutput = input + hysteresis;
    }
    return lastOutput;
}*/
//===========================================================================================



//===========================================================================================
void Pi_Calc(Tpi * pi, float Ref, float Input)
{
	
    pi->Err = Ref - Input;																				// ошибка регулирования
		//pi->Err = ApplyDeadzone( pi->Err );														// зона чувствительности
		//pi->Err = ApplyHysteresis( pi->Err );													// гистерезис
    pi->Up = pi->Kp * pi->Err;																		// пропорциональная составляющая
		pi->Ui = pi->Ui + pi->Ki * pi->Err;														// интегральная составляющая
		// ограничитель интегральной составляющей
    if (pi->Ui > pi->OutMax)		pi->Ui = pi->OutMax;
    else 
    if (pi->Ui < pi->OutMin)		pi->Ui = pi->OutMin;	
		    
    pi->Ud = pi->Kd * (pi->Err - pi->PrevErr);								// Дифференциальная составляющая
		pi->PrevErr = pi->Err;  																	// Сохраняем текущую ошибку для следующего расчета
	
    pi->Output = pi->Up + pi->Ui + pi->Ud;										// сумма составляющих

		// ограничитель
    if (pi->Output > pi->OutMax)		pi->Output = pi->OutMax;
    else 
    if (pi->Output < pi->OutMin)		pi->Output = pi->OutMin;

}
//===========================================================================================



//===========================================================================================
void Pi_Reset(Tpi * pi)
{

	pi->Err = 0.0f;
	pi->Up = 0.0f;
	pi->Ui = 0.0f;
	pi->Output = 0.0f;
	
}
//===========================================================================================




void Zi_Calc(Tzi *zi, float Uin) {
    const float epsilon = 0.001f; // Малое значение для сравнения чисел с плавающей точкой
    const float outputMax = 1000.0f; // Максимальное значение для интегратора (настройте под вашу систему)
    const float outputMin = -1000.0f; // Минимальное значение для интегратора (настройте под вашу систему)

    //--- Релейный элемент ---------------------------------------------------------------
    if (Uin > zi->Output + epsilon) {
        zi->UMax = SPEED_MAX; // Движение в положительном направлении
    } 
    else if (Uin < zi->Output - epsilon) {
        zi->UMax = -SPEED_MAX; // Движение в отрицательном направлении
    } 
    else {
        zi->UMax = 0.0f; // Остановка, если Uin и Output почти равны
    }

    //--- Интегратор --------------------------------------------------------------------
    zi->Output += zi->Ki * zi->UMax;

    //--- Ограничение выхода интегратора ------------------------------------------------
    if (zi->Output > outputMax) {
        zi->Output = outputMax;
    } 
    else if (zi->Output < outputMin) {
        zi->Output = outputMin;
    }
}

#if(0)
//===========================================================================================
//---Функция вычисления задатчика интенсивности----------------------------------------------
void Zi_Calc( Tzi * zi, float Uin ) {

	//---Релейный элемент----------------------------------------------------------------------
	if( Uin > zi->Output )
		zi->UMax = SPEED_MAX;//POS_MAX;
	else	if( Uin == zi->Output )
					zi->UMax = 0.0f;
				else	if( Uin < zi->Output )
								zi->UMax = -SPEED_MAX;//-POS_MAX;
	
	//---Интегратор----------------------------------------------------------------------------			
	zi->Output = zi->Output + zi->Ki * zi->UMax;																	

}
//===========================================================================================
#endif
