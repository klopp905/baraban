# Keil uVision project cube.uvprojx, settings and files
target cube (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: baraban_fm +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --elf --output C:\Work\BARABAN\baraban_v1\BARABAN_HAL\keil\MDK-ARM\FreeMaster\baraban_fm.elf C:\Work\BARABAN\baraban_v1\BARABAN_HAL\keil\MDK-ARM\OBJ\baraban_fm.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F031x6, USE_FULL_ASSERT
  c include: ..\;..\Inc;..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_HAL_Driver\Inc;..\Libraries\STM32F0xx_HAL_Driver\Inc\Legacy;..\Libraries\CMSIS\Include;..\Libraries\FreeMaster\Inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f031x6.s
  group User
    ../Src/: main.c stm32f0xx_it.c periph.c D808.c delays.c pi.c protocol.c stepdir.c buttons.c flash.c
  group HAL
    ../Libraries/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_adc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_spi.c
  group CMSIS
    ../Src/: system_stm32f0xx.c
  group FreeMaster
    ../Libraries/FreeMaster/Src/: PC_M1.c
software components: CMSIS:CORE 5.5.0
